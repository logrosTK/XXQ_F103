# Keil uVision project BH-STM32.uvprojx, settings and files
target beep (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Components
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h core_cm3.c
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c app_uart.c app_ps2.c app_motor.c app_sensor.c
  group Components
    ../../User/Components/y_delay/: y_delay.c
    ../../User/Components/y_global/: y_global.c
    ../../User/Components/y_kinematics/: y_kinematics.c
    ../../User/Components/y_led/: y_led.c
    ../../User/Components/y_motor/: y_motor.c
    ../../User/Components/y_servo/: y_servo.c
    ../../User/Components/y_timer/: y_timer.c
    ../../User/Components/y_usart/: y_usart.c
    ../../User/Components/y_encoder/: y_encoder.c
    ../../User/Components/ps2/: y_ps2.c
    ../../User/Components/tracking/: tracking.c
    ../../User/Components/flash/: y_flash.c
    ../../User/Components/soft_i2c/: y_soft_i2c.c
    ../../User/Components/oled/: y_oled.c
    ../../User/Components/resource/: resource.c
    ../../User/Components/y_ADC/: y_ADC.c
    ../../User/Components/y_beep/: y_beep.c
    ../../User/Components/key/: key.c
    ../../User/Components/ultrasonic/: ultrasonic.c
